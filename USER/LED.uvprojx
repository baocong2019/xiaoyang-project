# Keil uVision project LED.uvprojx, settings and files
target LED (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\delay;..\HARDWARE\DHT11;..\HARDWARE\usart2;..\HARDWARE\Key\Key;..\HARDWARE\Tongyong_Tim;..\HARDWARE\DHT22;..\HARDWARE\Utils;..\HARDWARE\Gizwits;..\HARDWARE\PID;..\HARDWARE\AdvanceTim
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: Lcd_Driver.c QDTFT_demo.c GUI.c
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/usart2/: usart2.c
    ../HARDWARE/Key/Key/: bsp_key.c
    ../HARDWARE/Tongyong_Tim/: Tongyong_Tim.c
    ../HARDWARE/DHT22/: dht22.c
    ../HARDWARE/Gizwits/: gizwits_product.c gizwits_protocol.c
    ../HARDWARE/Utils/: common.c dataPointTools.c ringbuffer.c
    ../HARDWARE/AdvanceTim/: bsp_AdvanceTim.c
    ../HARDWARE/PID/: pid.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group README
    ../: README.TXT
